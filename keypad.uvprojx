# Keil uVision project keypad.uvprojx, settings and files
target KeypadFreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keypad
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Program\FreeRTOS\include;.\Program\FreeRTOS\MemMang;.\Program\FreeRTOS;.\Program\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./program/src/: initialization.c main.c FreeRTOSConfig.h initialization.h main.h
  group FreeRTOS
    ./program/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c port.c
    ./program/FreeRTOS/MemMang/: heap_1.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
